# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,AIR001_DEV
  c include: ..\..\Libraries\BSP\AIR001_Core_Board;..\..\Libraries\CMSIS\Device\AIR001xx\Include;..\Inc;..\..\Libraries\AIR001xx_HAL_Driver\Inc;..\..\Libraries\CMSIS\Include;..\LPTimer;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Common
    ./: startup_air001_dev.s
    ../Src/: system_air001xx.c
  group Application/User
    ../Src/: main.c air001xx_hal_msp.c air001xx_it.c
    ../LPTimer/: LpTimer.c
  group Drivers/AIR001xx_HAL_Driver
    ../../Libraries/AIR001xx_HAL_Driver/Src/: air001xx_hal.c air001xx_hal_cortex.c air001xx_hal_dma.c air001xx_hal_flash.c air001xx_hal_gpio.c air001xx_hal_lptim.c air001xx_hal_pwr.c air001xx_hal_rcc.c air001xx_hal_rcc_ex.c air001xx_hal_uart.c
  group BSP
    ../BSP/: LED.c UART1.c LPTIM.c
software components: CMSIS:CORE 5.6.0
